# Keil uVision project STM32_UART_CMD.uvprojx, settings and files
target STM32_PUL_WHILE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\DRIVERS;..\hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ../BSP/: Emm_V5.h Emm_V5.c usart.c usart.h board.c board.h car.c car.h task.c task.h
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group DRIVERS
    ../DRIVERS/: fifo.c fifo.h delay.c delay.h
  group hardware
    ../hardware/: uart_3.c uart_3.h heading.c heading.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
